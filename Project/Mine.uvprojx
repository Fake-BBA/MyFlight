# Keil uVision project Mine.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mine
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\System\Core\Inc;..\System\Std_Lib\Inc;..\User\Inc;..\Devices\Drivers\Inc;..\Devices\Hardware\Inc;..\Devices\Independence\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Core
    ../System/Core/Src/: stm32f30x_misc.c
    ../System/Core/Inc/: core_cm4.h stm32f30x_misc.h
    ../System/Core/: startup_stm32f303xc.s
  group Hardware
    ../Devices/Hardware/Inc/: Har_Buzzer.h Har_HMC5883L.h Har_LED.h Har_MPU6050.h Har_MS5611.h Har_stm32_dma.h Har_Uart.h Har_W25Q64.h Har_SysTick.h
    ../Devices/Hardware/Src/: Har_Buzzer.c Har_HMC5883L.c Har_LED.c Har_MPU6050.c Har_MS5611.c Har_stm32_dma.c Har_Uart.c Har_W25Q64.c Har_SysTick.c
  group Drivers
    ../Devices/Drivers/Inc/: Dri_Buzzer.h Dri_HMC5883L.h Dri_LED.h Dri_MPU6050.h Dri_MS5611.h Dri_Uart.h Dri_W25Q64.h Dri_SysTick.h
    ../Devices/Drivers/Src/: Dri_Buzzer.c Dri_HMC5883L.c Dri_LED.c Dri_MPU6050.c Dri_MS5611.c Dri_Uart.c Dri_W25Q64.c Dri_SysTick.h.c
  group StdLib
    ../System/Std_Lib/Src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c stm32f30x_hrtim.c system_stm32f30x.c
  group User
    ../User/Src/: main.c stm32f3xx_it.c Queue.c
    ../User/Inc/: MyConfiguration.h MyTypedef.h stm32f3xx_it.h Devices.h main.h stm32f30x_conf.h Queue.h
    ../: ReadMe.txt
